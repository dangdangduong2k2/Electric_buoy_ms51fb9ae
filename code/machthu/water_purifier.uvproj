# Keil uVision project water_purifier.uvproj, settings and files
target water_purifier (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: water_purifier +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\library
  group Source
    ./: main.c
